# Keil uVision project CAN_MAJOR_PROJECT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: CAN_MAJOR_PROJECT +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s can.c lcd.c delay.c adc.c adc_node_tx.c indicator_node_rx.c interrupt.c main_functions.c main_tx_rx.c MMA7660.c i2c.c main_airbag_trigger.c lcd_test.c
